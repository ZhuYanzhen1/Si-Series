# Keil uVision project Project.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: Project +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\USER
  group Main
    ./: main.c
  group User
    ./USER/: PWM.c Serial.c LCD1602.c AnalogToDigital.c DS18B20.c 74HC573.c System_Config.c User_Program.c Data_Convert.c Startup.c STC12_IT.c EEPROM.c

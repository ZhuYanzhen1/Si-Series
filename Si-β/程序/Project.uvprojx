# Keil uVision project Project.uvprojx, settings and files
target Project (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c include: .\Libraries\CMSIS;.\User;.\Libraries\STM32F10x_StdPeriph_Driver\inc;.\App;.\Public;.\FreeRTOS
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group User
    ./User/: main.c stm32f10x_it.c
  group Startup
    ./Libraries/CMSIS/: startup_stm32f10x_hd.s
  group CMSIS
    ./Libraries/CMSIS/: core_cm3.c system_stm32f10x.c
  group StdPeriph_Driver
    ./Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_dac.c stm32f10x_exti.c stm32f10x_dma.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c
  group App
    ./App/: USART.c sram.c W25Q64.c DS18B20.c Beep.c DAC.c adx345.c
    ./User/: User.c
  group Public
    ./Public/: System.c
  group LCD
    ./App/: GUI.c LCD.c Touch.c
  group Camera
    ./App/: Camera.c Camera_SCCB.c
  group SPI
    ./App/: SPI2.c SPI1.c SPI3.c
  group IIC
    ./App/: IIC1.c IIC2.c
  group FreeRTOS
    ./FreeRTOS/: croutine.c event_groups.c heap_4.c list.c port.c queue.c tasks.c timers.c
